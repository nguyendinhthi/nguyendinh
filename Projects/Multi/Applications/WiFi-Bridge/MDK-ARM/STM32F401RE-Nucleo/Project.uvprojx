# Keil uVision project Project.uvprojx, settings and files
target STM32F401RE_Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: STM32F401RE_Nucleo-WiFi-Bridge +hex
  AfterMake: fromelf --bin -o STM32F401RE_Nucleo\STM32F401RE_Nucleo-WiFi-Bridge.bin STM32F401RE_Nucleo\STM32F401RE_Nucleo-WiFi-Bridge.axf
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: X_NUCLEO_IDS01A4,CONSOLE_UART_ENABLED,SPWF01,USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USART_PRINT_MSG,SKIP_LIFETIME=1,PROJECT_CONF_H=1,MY_DRIVERS=1,WITH_IP64=1,USE_SPIRIT1_DEFAULT,WITH_UIP6,WITH_UIP,CONTIKI=1,UIP_CONF_TCP=1,NETSTACK_CONF_WITH_IPV6=1,UIP_CONF_IPV6_RPL=1,AUTOSTART_ENABLE=1,USE_X_CUBE_IDW01M1
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Utils;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW0xx1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc;..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library;..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev;..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc;..\..\..\..\..\..\Middlewares\Third_Party\Contiki;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip64;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\mac;..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/SPIRIT1
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers\BSP\STM32F4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers\CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group WiFi-Bridge\MDK-ARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Drivers\BSP\X-NUCLEO-IDW0xx1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW0xx1/: stm32_spwf_wifi.c
  group Applications\WiFi-Bridge\Src
    ../../Src/: cube_hal_f4.c ip64-router.c main.c my_wifi_driver.c my_wifi_interface.c my_wifi_map.c wifi_support.c stm32_xx_it.c console.c stm32_xx_hal_msp.c
  group Drivers\STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Middlewares\STM32_SPWF0xSy
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/: wifi_interface.c wifi_module.c wifi_module_spi.c wifi_module_uart_01.c wifi_module_uart_04.c
  group Middlewares\Utils
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/Utils/: ring_buffer.c event_buffer.c wifi_globals.c spwf04WiFi.c
  group Middlewares/STM32_Contiki_Library
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: button-sensor.c leds-arch.c radio-sensor.c
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: clock.c console.c contiki-spirit1-main.c node-id.c rtimer-arch.c spirit1.c spirit1-arch.c watchdog.c
  group Middlewares/Contiki/core/dev
    ../../../../../../Middlewares/Third_Party/Contiki/core/dev/: leds.c
  group Middlewares/Contiki/core/lib
    ../../../../../../Middlewares/Third_Party/Contiki/core/lib/: memb.c random.c sensors.c list.c
  group Middlewares/Contiki/core/net
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/: linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c link-stats.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: ip64-addr.c psock.c resolv.c simple-udp.c tcpip.c udp-socket.c uip-debug.c uiplib.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group Middlewares/Contiki/core/net/ip64
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ip64/: ip64-addrmap.c ip64-dns64.c ip64-special-ports.c ip64.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: csma.c frame802154.c frame802154e-ie.c framer-802154.c framer-nullmac.c mac.c mac-sequence.c nordc.c nullmac.c nullrdc.c nullrdc-noframer.c phase.c
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c rpl-nbr-policy.c
  group Middlewares/Contiki/core/sys
    ../../../../../../Middlewares/Third_Party/Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c process.c procinit.c rtimer.c stimer.c timer.c
